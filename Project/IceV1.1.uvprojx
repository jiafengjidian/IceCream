# Keil uVision project IceV1.1.uvprojx, settings and files
target IceV1.1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: IceV1.1
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_USB_OTG_FS,__TARGET_FPU_VFP
  c include: ..\CMSIS;..\User;..\User\Usb\APP;..\User\Usb\DEVICE\hid\inc;..\User\Usb\DEVICE\inc;..\User\Usb\OTG\inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CMSIS
    ../CMSIS/: system_stm32f4xx.c startup_stm32f40_41xxx.s
  group User
    ../User/: main.c SysTimer.c xString.c BluetoothProtocol.c
  group User/Periph
    ../User/Periph/: PeriphFsmc.c PeriphTimer.c
  group User/Device
    ../User/Device/: DeviceLcd.c DeviceLed.c DeviceCh451s.c DeviceBluetooth.c DeviceMoto.c DeviceNrf2401.c Device74HC165.c
  group Task
    ../User/Task/: Ch451sTask.c BluetoothReceiverTask.c TimerTask.c MotoControlTask.c MotoUpDownControlTask.c StatusCheckTask.c
  group Usb/OTG
    ../User/Usb/OTG/src/: usb_dcd.c usb_dcd_int.c usb_core.c
  group Usb/Device
    ../User/Usb/DEVICE/src/: usbd_core.c usbd_ioreq.c usbd_req.c
    ../User/Usb/DEVICE/hid/src/: usbd_hid_core.c
  group Usb/App
    ../User/Usb/APP/: usbd_usr.c usbd_desc.c usb_bsp.c usb_it.c
software components: CMSIS:CORE 5.1.1, CMSIS:RTOS2:Keil RTX5 5.3.0
